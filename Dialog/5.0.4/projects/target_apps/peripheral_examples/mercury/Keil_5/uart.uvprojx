# Keil uVision project uart.uvprojx, settings and files
target UART_SENSOR (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta4
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: uart +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c
  c include: ..\include;..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\sdk\platform\include;..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\shared\common_uart;..\..\..\..\..\sdk\platform\driver\uart;.\mcube;..\src
  library: MicroLIB
  memory RVCT9: RAM 0x200000 size 0x9800
  scatter file: ..\..\shared\peripheral_examples.sct
  group boot
    ../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
    ../src/: i2c_core.c
  group common_uart
    ../../shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
  group mCube
    ./mcube/: m_drv_mc3630.c m_drv_mc_utility.c
